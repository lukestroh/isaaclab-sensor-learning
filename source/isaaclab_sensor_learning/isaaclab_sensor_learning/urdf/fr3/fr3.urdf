Commit message: fr3 is bad, trying out UR10e

File: source/isaaclab_sensor_learning/isaaclab_sensor_learning/urdf/fr3/fr3.urdf (robot description, URDF)
Before this commit: robot fr3, 22 links, 21 joints
Links:
- link fr3_link8: mass None -> 0.001
